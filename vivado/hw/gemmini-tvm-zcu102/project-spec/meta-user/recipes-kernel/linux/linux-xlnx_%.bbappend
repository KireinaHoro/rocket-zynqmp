SRC_URI += "file://bsp.cfg \
            file://devtool-fragment.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
